# Keil uVision project PROJECT.uvprojx, settings and files
target PROJECT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PROJECT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\START;..\HARDWARE\inc;..\USER;..\ALG\inc;..\APP\inc;..\INTERFACE\inc;..\USER\inc;..\CORE\inc;..\cm_backtrace;..\SEGGERRTT\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  memory RVCT10: RAM 0x20001000 size 0x4000
  group START
    ../START/: Cortex-M3-Start.s
  group CORE
    ../CORE/src/: interrupt.c
  group HARDWARE
    ../HARDWARE/src/: adc.c can.c delay.c dma.c flash.c gpio.c system.c timer.c usart.c wdg.c spi.c i2c.c
  group INTERFACE
    ../INTERFACE/src/: device.c spiflash.c sd.c
  group APP
    ../APP/src/: flashapply.c
  group ALG
    ../ALG/src/: arithmetic.c
  group USER
    ../USER/src/: main.c
  group SEGGERRTT
    ../SEGGERRTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
